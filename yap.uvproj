# Keil uVision project yap.uvproj, settings and files
target yap (ARM-GNU)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: yap
  AfterMake: objdump.bat
  group include
    ./include/: s3c24xx.h system.h uart.h common.h head.h i_socket.h arp.h DM9000.h pcb.h spinlock_types.h
  group kernel
    ./kernel/: main.c syscall.c assert.c config.c interrupt.c atomic.c bitops.c bug.c changebit.c machine.c
  group proc
    ./proc/: pcb.c proc.c spinlock.c preempt.c binfmt_aout.c elf.c exec.c fork.c mutex.c prosser.c sched.c
  group arch
    ./arch/arm/: head.S s3c24xx_irq.c init_system.c init.c init_task.c irqflags.c mach-s3c24xx.c pagealloc.c pgtable.c traps.c
    ./arch/arm/asm/: arch_spinlock.c
  group driver
    ./driver/: key.c led.c block_dev.c char_dev.c timer.c device.c nand.c test_platform.c led_device.c led_driver.c platform.c
    ./driver/serial/: s3c24xx.c
    ./driver/tty/: tty.c
    ./driver/net/: net_dev.c DM9000.c
    ./driver/spi/: spi.c spi_s3c24xx.c spi_jz2440_info.c spi_oled.c
  group lib
    ./lib/: printk.c lib.c list.c
  group ipc
    ./ipc/: message.c
  group fs
    ./fs/: ramdisk.c ramfs.c vfs.c ofs.c romfs.c inode.c
  group mm
    ./mm/: kmalloc.c mm.c filemap.c memory.c mmap.c page_alloc.c slab.c swap.c bootmem.c
  group user
    ./user_program/: user_syscall.s
  group net
    ./net/inet/: inet_socket.c raw.c tcp.c udp.c arp.c eth.c icmp.c ip.c inet.c
    ./net/: socket.c netif.c
  group test
    ./test/: oled.c
target nor (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: TQ2440_Test +hex
  AfterMake: fromelf.exe --bin -o @p.bin output/@p.axf
  c flags: Optim=1
  c include: ./inc
  asm include: ./inc
  memory RVCT1: ROM 0x0 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x800000
  memory RVCT9: RAM 0x40000000 size 0x1000
  link misc: --sort=CallTree
